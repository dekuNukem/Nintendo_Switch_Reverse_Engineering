# Keil uVision project switchmod_code.uvprojx, settings and files
target switchmod_code (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: switchmod_code
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: ../Inc;                                ../Drivers/STM32F0xx_HAL_Driver/Inc;                                ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                ../Drivers/CMSIS/Include;                         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                         ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_it.c main.c stm32f0xx_hal_msp.c helpers.c max572x.c usbd_conf.c usb_device.c usbd_cdc_if.c usbd_desc.c my_usb.c cmd_parser.c delay_us.c joycon_cmd.c
    ../Inc/: helpers.h shared.h max572x.h my_usb.h cmd_parser.h delay_us.h joycon_cmd.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_tim.c stm32f0xx_hal_i2c.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.1.0
